Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 8ded863a-fef2-49e7-b83e-72eb26fb6669, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: 47170120(2024).ifc
Time: 2025-01-29T22:03:35
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1; sets with these values: 2
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: 8mm Head; Type: 8mm Head; Type Id: 305
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 8mm Head
Other(Type) - Category: Levels; Family Name: Level

# IfcFlowController: 47170120(2024):47170120 Hand shower set, 47170120(2024):47170120 Hand shower set:389810
In: Level 1
Type - PredefinedType: FAUCET; Material: Chrome
Type - General - Author: BIMStone; BIMObjectName: 47170120(2024); ManufacturerName: HANSA; ManufacturerURL: http://www.hansa.com; NBSDescription: Shower heads; NBSReference: 45-35-70/333; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_76; Uniclass2015Description: Shower heads; Uniclass2015Reference: Pr_40_20_87_76; Version: 1; VersionDate: 20/08/2024
Type - Green Building Properties - EN Standard: EN 1112, EN 1113; ETIM Class Number: EC010161 Hand shower; Noise Class: I (ISO 3822); UNSPSC Class Number: 30181803 Hand held shower unit; URL Declaration of Asbestos: http://static.hansa.com/doc/asbestos; URL Declaration of Conformity: http://static.hansa.com/DoC/47170120; URL Declaration Of Performance (DOP): http://static.hansa.com/doc/DoP; URL Declaration of SCIP: http://static.hansa.com/doc/SCIP; URL EcoLabel Declaration: http://static.hansa.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.hansa.com/doc/packaging; URL Materials Declaration: http://www.hansa.com/fileadmin/resources/196595_47170120_materialsdeclaration.pdf; URL REACH: http://static.hansa.com/doc/reach
Type - Constraints - Default Elevation: 0 mm
Type - Mechanical - Advanced Features: Anti-twist hose connector; Connection Size: G1/2; Flow Rate At 300kPa With Flow Reducers: 0.2 dm3/s; Hand Shower Size: Ø 110 mm; Installation Type: Wall mounted; Max. Hot Water Supply: 65 C; Shower Parts: Hand shower;Shower holder;Shower hose (1250 mm);Anti limescale technology (easy to clean);Twist guard for shower hose; Shower Spray: Pulsating - Strong water stream for massage or body treatment;Intense - invigorating water stream;Relaxing - Soft water stream, pleasant for entire body; Shower Spray Number: 3 spray functions; Surface treatment: Chrome; Working Pressure: 50 - 500 kPa
Type - Materials and Finishes - FaucetMainMaterial: Chrome
Type - Construction - Type: 0 mm
Type - Dimensions - NominalDepth: 107 mm; NominalHeight: 352 mm; NominalWidth: 122 mm
Type - Identity Data - 3D View: https://static.hansa.com/3D/47170120; Catalog Drawing URL: http://static.hansa.com/catdrw/47170120; Category B2C: Shower solutions; Color variants: 4717012033;4717012080;4717012081; Dimension Drawing URL: http://static.hansa.com/dimdrw/47170120; FDV Document URL: http://www.hansa.com/datasheet/47170120/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/47170120; Group: Hand shower set; Installation and Maintenance Guide URL: http://static.hansa.com/manual/47170120; Interactive AR View URL: https://static.hansa.com/AR/47170120; Long Marketing: HANSAAURELIA A Symphony of Simplicity and Elegance. Discover the harmony of HANSAAURELIA, a symphony of simplicity and elegance. AURELIA draws design inspiration from the exquisite elements of wild nature. From the graceful Lotus flower transformed into a spray face, designed for pure enjoyment, to the simplest curve of a tiny waterdrop shaping our hand shower, each detail reflects the beauty surrounding us in nature. Grace is key to every element, creating a seamless connection between form and function. 110mm – 3 spray face Handshower Easy push diverter for simple selection of spray face Elegant shower holder ELEVATING YOUR MOMENTS; Manufacturer: HANSA; Market: International;Poland;Germany;Austria;Switzerland;Belgium;Netherlands;Czech Republic;Slovakia;Italy; Mobile Product Information URL: http://mpi.hansa.com/47170120; Model: 47170120 Hand shower set; Name_en: 47170120 Hand shower set; OmniClass Number: 23.45.55.00; Product Code: 47170120; Product Family: HANSAAURELIA; Product Image URL: http://static.hansa.com/image/47170120; Product URL: http://static.hansa.com/47170120; Technical DataSheet URL: http://www.hansa.com/datasheet/47170120/en; Type Name: 47170120 Hand shower set; Warranty Information URL: http://warranty.hansa.com
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: HANSA; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 47170120(2024); Features: n/a; Finish: Polished; Grade: n/a; Material: Brass/Plastic; ModelNumber: n/a; ModelReference: 47170120; Name: 47170120 Hand shower set; ReplacementCost: n/a; Shape: Sculptured; Size: 95 x 60 x 245 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Chrome
Type - Pset_ManufacturerTypeInformation - ModelReference: 47170120; Manufacturer: HANSA
Type - Pset_ProductRequirements - Name: 47170120 Hand shower set
Type - Pset_ValveTypeCommon - ValvePattern: OTHER; ValveOperation: OTHER; ValveMechanism: OTHER; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 47170120 Hand shower set; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Phasing - Phase Created: New Construction
Dimensions - Area: 0.0936097 m2; Volume: 0.00458991 m3
Identity Data - Mark: 15
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 47170120(2024); Family and Type: 47170120(2024): 47170120 Hand shower set; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 47170120 Hand shower set; Type Id: 389788; WarrantyStartDate: n/a
